# Keil uVision project SDCFile.uvproj, settings and files
target SDCFile (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: SDCFile
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ./: startup.s diskio.c ff.c PLL.c SDCFile.c ST7735.c jpg2bmp.c
  group Picojpeg
    ./: picojpeg.c picojpeg.h
  group Heap
    ./: heap.c heap.h
  group Camera
    ./: FiFo.c DEBUG_UART.c Camera.c Uart1.c Uart1.h FiFo.h DEBUG_UART.h Camera.h
