# Keil uVision project ST7735.uvproj, settings and files
target ST7735 (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ST7735
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ./: startup.s ST7735.c ST7735TestMain.c PLL.c
