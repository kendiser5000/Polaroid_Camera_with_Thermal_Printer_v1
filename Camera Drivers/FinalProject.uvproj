# Keil uVision project FinalProject.uvproj, settings and files
target FinalProject (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: ADCSWTrigger
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s ADCTestMain.c PLL.c ST7735.c ST7735.h FiFo.c Camera.c Uart1.c FiFo.h Camera.h Uart1.h DEBUG_UART.c DEBUG_UART.h
